# Keil uVision project L0_ADC_DEMO.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32L031K6Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: L0_ADC_DEMO
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: main.c main.h delay.c delay.h Adafruit_SSD1306.c Adafruit_SSD1306.h Adafruit_GFX.h Adafruit_GFX.cpp Arduino.h gfxfont.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.12.2
